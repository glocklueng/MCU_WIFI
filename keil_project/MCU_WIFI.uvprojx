# Keil uVision project MCU_WIFI.uvprojx, settings and files
target STM32F4_UCOSII (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MCU_WIFI
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\app\inc;..\bsp\stm32f4xx\CMSIS\inc;..\bsp\stm32f4xx\FWlib4xx\inc;..\kernel\api\inc;..\kernel\ucos\include;..\config;..\drivers\stm32f4xx\inc;..\net\RT5572_RT5372_Linux_AP_V2.7.1.0_DPA_20120815\MODULE\include;..\net\lwip\src\include;..\net\lwip\src\include\ipv4;..\drivers\stm32f4xx\usb\STM32_USB_HOST_Library\inc;..\drivers\stm32f4xx\usb\inc;..\drivers\stm32f4xx\usb\STM32_USB_OTG_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../app/src/: main.c debug.c
  group BSP
    ../bsp/stm32f4xx/CMSIS/src/: system_stm32f4xx.c startup_stm32f40_41xxx.s
    ../bsp/stm32f4xx/FWlib4xx/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group OS
    ../kernel/ucos/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../kernel/ucos/uCOS-II/Ports/ARM-Cortex-M3/IAR/: os_cpu_a.asm os_cpu_c.c
  group OSAPI
    ../kernel/api/src/: atomic.c mbox.c memory.c msg_q.c mutex.c sem.c task.c timer.c wait.c
